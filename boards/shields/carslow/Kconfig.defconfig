## boards/shields/carslow/Kconfig.defconfig
```kconfig
if SHIELD_CARSLOW

config ZMK_KEYBOARD_NAME
    default "carslow"

endif # SHIELD_CARSLOW
```
